# IAR project loratx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; CFG_sx1276_radio
  ICCARM.CCIncludePath2: ..\..\Source\Libraries\STM32_USB-FS-Device_Lib_V4.1.0\STM32_USB-FS-Device_Driver\inc; ..\..\Source\Libraries\STM32_USB-FS-Device_Lib_V4.1.0\STM32F10x_StdPeriph_Driver\inc; ..\..\Source\Libraries\STM32_USB-FS-Device_Lib_V4.1.0\CMSIS\Device\ST\STM32F10x\Include; ..\..\Source\Bsp_SX127x; ..\..\Source\Libraries\STM32_USB-FS-Device_Lib_V4.1.0\CMSIS\Include; inc; src\board; ..\..\Source\Libraries\kernel\meos; ..\..\Source\Libraries\Common; ..\..\Source\Libraries\radio; src; ..\..\Source\Libraries\base64
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: loratx.out
  ILINK.IlinkIcfFile: loratx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app/src
    src/: app.c at.c gateway.c main.c stm32_it.c system_stm32f10x.c verify.c virtualComPort.c
    src/board/: hw_config.c stm3210e_eval.c
  group app/src/usb
    src/usb/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group lib/base64
    ../../Source/Libraries/base64/: base64.c
  group lib/comm
    ../../Source/Libraries/Common/: common.c crc.c ringbuf.c
  group lib/radio
    ../../Source/Libraries/radio/: radio.c sx127x.c
  group lib/std
    ../../Source/Libraries/STM32_USB-FS-Device_Lib_V4.1.0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_wwdg.c
    ../../Source/Libraries/STM32_USB-FS-Device_Lib_V4.1.0/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_xl.s
  group lib/usb
    ../../Source/Libraries/STM32_USB-FS-Device_Lib_V4.1.0/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group os/meos
    ../../Source/Libraries/kernel/meos/: os.asm os_shed.c
