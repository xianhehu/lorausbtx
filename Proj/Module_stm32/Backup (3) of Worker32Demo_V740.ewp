# IAR project Backup (3) of Worker32Demo_V740.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030X8; _MCU_STM32_; USE_STDPERIPH_DRIVER; HSE_32M
  ICCARM.CCIncludePath2: ..\Source\User; ..\Source\Drives; ..\Source\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\Source\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\Source\Bsp_sx127x; ..\Source\Q_Shell
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Worker32Demo_V740.hex
  ILINK.IlinkOutputFile: Worker32Demo_V740.out
  ILINK.IlinkIcfFile: Proj_stm32f030x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F030; _MCU_STM32_; USE_STDPERIPH_DRIVER; HSE_32M
  ICCARM.CCOptLevel: 3
  group (top)
    ../Source/: Proj Set.txt
  group Bsp_sx127x
    ../Source/Bsp_sx127x/: Drv_Spi.c Drv_sx127x.c Drv_SX127x_IOCTL.c
  group Drives
    ../Source/Drives/: Drv_IOCtl.c Drv_MonLCD.c Drv_Usart.c gps.c UC1701X_Drive.c
  group Libraries/CMSIS
    ../Source/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
    ../Source/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Libraries/STM32F0xx_StdPeriph_Driver
    ../Source/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Libraries/STM32F0xx_StdPeriph_Driver/NotUsed
    ../Source/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_rtc.c
  group Q_Shell
    ../Source/Q_Shell/: Drv_Usart_QShell.c Q_Shell.c
  group User
    ../Source/User/: Main.c Q_Shell_User.c stm32f0xx_it.c
