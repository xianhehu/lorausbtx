<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Worker32Demo_V740.ewp</path>
  </project>
  <batchBuild/>
</workspace>


